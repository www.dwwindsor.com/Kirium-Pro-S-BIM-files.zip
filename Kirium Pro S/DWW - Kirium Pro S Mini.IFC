Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: DWW - Kirium Pro S Mini.IFC
Time: 2023-11-29T11:58:58
Written by: SwIFC
Made in: SolidWorks 2018

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DWW - Kirium Pro S Mini
In: Default Storey
PredefinedType: ELEMENT; Material: 0
